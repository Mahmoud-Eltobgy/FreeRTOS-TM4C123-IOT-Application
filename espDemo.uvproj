# Keil uVision project espDemo.uvproj, settings and files
target esp8266 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: esp8266
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c misc: --C99
  c include: ..;..\..\..;.\FreeRTOS\Source\include;.\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s main.c pll.c esp8266.c UART.c FreeRTOSConfig.h adc.c adc.h
    ./FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ./FreeRTOS/Source/portable/MemMang/: heap_1.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
